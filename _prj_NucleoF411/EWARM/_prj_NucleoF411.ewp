# IAR project _prj_NucleoF411.ewp, settings and files
configuration _prj_NucleoF411 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE; NUCLEO_F411RE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\Users\visconta\Projects\STdC\lsm6dsv16x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\FIFO_Utility_Tool; C:\Users\visconta\Projects\STdC\lsm6dsv16bx_STdC\driver; C:\Users\visconta\Projects\STdC\lsm6dsv32x_STdC\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _prj_NucleoF411.hex
  ILINK.IlinkOutputFile: _prj_NucleoF411.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group lsm6dsv16bx
    ../../lsm6dsv16bx_STdC/examples/: lsm6dsv16bx_activity.c lsm6dsv16bx_fifo.c lsm6dsv16bx_pedometer.c lsm6dsv16bx_qvar_read_data_polling.c lsm6dsv16bx_read_data_polling.c lsm6dsv16bx_self_test.c lsm6dsv16bx_sensor_fusion.c lsm6dsv16bx_tdm_conf.c lsm6dsv16bx_wake_up.c
    ../../lsm6dsv16bx_STdC/driver/: lsm6dsv16bx_reg.c
  group lsm6dsv16x
    ../../lsm6dsv16x_STdC/examples/: lsm6dsv16x_compressed_fifo.c lsm6dsv16x_fifo.c lsm6dsv16x_fifo_irq.c lsm6dsv16x_free_fall.c lsm6dsv16x_qvar_read_data_polling.c lsm6dsv16x_read_data_irq.c lsm6dsv16x_read_data_polling.c lsm6dsv16x_self_test.c lsm6dsv16x_sensor_fusion.c lsm6dsv16x_single_double_tap.c lsm6dsv16x_six_d_position.c lsm6dsv16x_wakeup.c
    ../../lsm6dsv16x_STdC/driver/: lsm6dsv16x_reg.c
  group lsm6dsv32x
    ../../lsm6dsv32x_STdC/examples/: lsm6dsv32x_fifo.c lsm6dsv32x_read_data_polling.c lsm6dsv32x_self_test.c lsm6dsv32x_sensor_fusion.c
    ../../lsm6dsv32x_STdC/driver/: lsm6dsv32x_reg.c
  group st_fifo
    ../../_resources/FIFO_Utility_Tool/: st_fifo.c
